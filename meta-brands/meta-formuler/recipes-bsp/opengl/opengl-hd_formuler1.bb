require opengl-hd.inc

COMPATIBLE_MACHINE = "formuler1"
