# meta package for enigma2 picon sets

require conf/license/license-gplv2.inc
inherit packagegroup

PR = "r0"
