
THIRDPARTY_PLUGINS_remove = " \
    enigma2-plugin-extensions-opkg-tools_1.4_mips32el.ipk \
    enigma2-plugin-extensions-opkg-tools_1.4_cortexa15hf-neon-vfpv4.ipk \
    "
